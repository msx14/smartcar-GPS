# Keil uVision project RT102X.uvprojx, settings and files
target nor_zf_ram_v5 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.12.1.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x00000000,0x010000) XRAM(0x20200000,0x020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RT102X
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __FPU_PRESENT,ARM_MATH_CM7,CPU_MIMXRT1021DAG5A,SKIP_SYSCLK_INIT,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, XIP_BOOT_HEADER_ENABLE =1,XIP_EXTERNAL_FLASH=1
  c misc: --library_interface=armcc --diag_suppress=66,1296,186,1
  c include: ..\CODE;..\USER\inc;..\USER\src;..\..\Libraries\librares\CMSIS\Include;..\..\Libraries\librares\cmsis_drivers;..\..\Libraries\librares\drives;..\..\Libraries\librares\startup;..\..\Libraries\librares\startup\MDK-ARM;..\..\Libraries\librares\utilities;..\..\Libraries\librares\utilities\debug_console;..\..\Libraries\librares\utilities\str;..\..\Libraries\librares\xip;..\..\Libraries\seekfree_librares;..\..\Libraries\seekfree_peripheral;..\..\Libraries\seekfree_librares\board;..\..\Libraries\librares\components\serial_manager;..\..\Libraries\librares\components\serial_manager\usb_cdc_adapter;..\..\Libraries\librares\components\uart;..\..\Libraries\librares\components\lists;..\..\Libraries\librares\deceive;..\..\Libraries\seekfree_librares\common;..\..\Libraries\seekfree_librares\board;..\..\Libraries\librares\nncu_mcu;..\..\Libraries\librares\nncu_mcu\aiann;..\..\Libraries\librares\nncu_mcu\cmsis_nn\Include;..\..\Libraries\librares\nncu_mcu\cmsis5\Include
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\scf\RT1021_nor_zf_ram_v5.scf
  link misc: --remove
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.conf)
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group doc
    ../../Libraries/doc/: version.txt read me.txt
  group drives
    ../../Libraries/librares/drives/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexio.c fsl_flexio_camera.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexram.c fsl_flexspi.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_qtmr.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_tempmon.c fsl_trng.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c fsl_iomuxc.h fsl_ocotp.c fsl_ocotp.h flexspi_nor_flash_ops.c flexspi_nor_flash_ops.h
  group startup
    ../../Libraries/librares/startup/MDK-ARM/: startup_MIMXRT1021.s
  group utilities
    ../../Libraries/librares/utilities/: fsl_assert.c usb_device_config.h
    ../../Libraries/librares/utilities/str/: fsl_str.c fsl_str.h
    ../../Libraries/librares/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group deceive
    ../../Libraries/librares/deceive/: fsl_device_registers.h MIMXRT1021.h MIMXRT1021_features.h system_MIMXRT1021.c system_MIMXRT1021.h
  group components
    ../../Libraries/librares/components/uart/: lpuart_adapter.c uart.h
    ../../Libraries/librares/components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
    ../../Libraries/librares/components/lists/: generic_list.c generic_list.h
  group seekfree_librares
    ../../Libraries/seekfree_librares/common/: common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
    ../../Libraries/seekfree_librares/: zf_gpio.c zf_gpio.h zf_iomuxc.c zf_iomuxc.h zf_pit.c zf_pit.h zf_pwm.c zf_pwm.h zf_uart.c zf_uart.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_qtimer.c zf_qtimer.h zf_adc.c zf_adc.h zf_iic.c zf_iic.h zf_camera.c zf_camera.h zf_flash.c zf_flash.h
  group seekfree_peripheral
    ../../Libraries/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h SEEKFREE_W25Q64.c SEEKFREE_W25Q64.h SEEKFREE_IPS200_PARALLEL8.c SEEKFREE_IPS200_PARALLEL8.h SEEKFREE_SCC8660.c SEEKFREE_SCC8660.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h
  group board
    ../../Libraries/seekfree_librares/board/: board.c board.h clock_config.c pin_mux.c
  group user_h
    ../../Libraries/seekfree_librares/: headfile.h
    ../USER/inc/: RT102X_config.h isr.h
  group user_c
    ../USER/src/: main.c isr.c
    ../CODE/: nncie_imxrt10x0.lib model.nncu.c smartcar_ad.nctv.c
  group xip
    ../../Libraries/librares/xip/: evkmimxrt1020_flexspi_nor_config.c evkmimxrt1020_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
  group cmsis_nn
    ../../Libraries/librares/nncu_mcu/cmsis_nn/Source/: arm_avepool_q7_HWC_nonsquare.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_nn_activations_q7.c arm_fully_connected_q15_opt.c arm_nn_activations_q15.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mult_q7.c arm_nn_mult_q15.c arm_nntables.c arm_pool_q7_HWC.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_relu_q7.c arm_relu_q15.c arm_softmax_q7.c arm_softmax_q15.c
  group XMU
    ../CODE/: ADCollection.c ADCollection.h GlobalVar.c GlobalVar.h Init.c Init.h keyboard.c keyboard.h SmotorConrol.c SmotorControl.h OLED.c OLED.h Screen.c Screen.h Menu.c Menu.h spd.c spd.h MCP4452.c MCP4452.h Bluetooth.c Bluetooth.h
target nor_zf_ram_v6 (::::)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.12.1.0
  cpu: as above
  output: RT102X
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\scf\RT1021_nor_zf_ram.scf
  link misc: as above
